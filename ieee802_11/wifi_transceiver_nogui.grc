options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_transceiver_nogui
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2452000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '2452000000'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '750'
  states: {state: disabled}
- name: interval
  id: variable
  parameters:
    value: '750'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {state: disabled}
- name: lo_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '150'
  states: {state: disabled}
- name: pdu_length
  id: variable
  parameters:
    value: '150'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 10e6
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("P" for i in range(pdu_length)))
    period: interval
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '52'
    type: complex
  states: {state: disabled}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '100000'
    pad_front: '10000'
    pad_tail: '10000'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_11_ether_encap_0
  id: ieee802_11_ether_encap
  parameters:
    debug: 'False'
  states: {state: disabled}
- name: ieee802_11_extract_csi_0
  id: ieee802_11_extract_csi
  parameters: {}
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    dst_mac: '[0x30, 0x14, 0x4a, 0xe6, 0x46, 0xe4]'
    src_mac: '[0x12, 0x34, 0x56, 0x78, 0x90, 0xab]'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {state: disabled}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    mtu: '440'
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Real
    label2: Img
    marker1: '0'
    marker2: '1'
    name: '"Channel State Information"'
    size: 52*1
    srate: samp_rate
    type: complex
    ymax: '80'
    ymin: '-40'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:64000
    timeout: '100'
    type: complex
    vlen: '52'
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:64001
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:64000
    timeout: '100'
    type: complex
    vlen: '52'
  states: {}

connections:
- [blocks_message_strobe_0_0, strobe, ieee802_11_mac_0, app in]
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1_0, '0']
- [foo_packet_pad2_0, '0', uhd_usrp_sink_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_ether_encap_0, to tap, network_tuntap_pdu_0, pdus]
- [ieee802_11_ether_encap_0, to wifi, ieee802_11_mac_0, app in]
- [ieee802_11_extract_csi_0, '0', blocks_vector_to_stream_0, '0']
- [ieee802_11_extract_csi_0, '0', zeromq_pub_sink_0, '0']
- [ieee802_11_extract_csi_0, '0', zeromq_push_sink_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [network_tuntap_pdu_0, pdus, ieee802_11_ether_encap_0, from tap]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0, '0']
- [wifi_phy_hier_0, carrier, pdu_pdu_to_tagged_stream_0, pdus]
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]
- [wifi_phy_hier_0, mac_out, ieee802_11_ether_encap_0, from wifi]
- [wifi_phy_hier_0, mac_out, ieee802_11_extract_csi_0, pdu in]
- [wifi_phy_hier_0, mac_out, ieee802_11_mac_0, phy in]
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]
- [zeromq_pull_msg_source_0, out, ieee802_11_mac_0, app in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
